# Keil uVision project rtc_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_CUSTOM CUSTOM_BOARD_BLUEMOD_S42_EVAL NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET NRF52
  c include: ..\..\config\rtc_pca10040;..\..\config;..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\toolchain;..\..\..\..\bsp;..\..
  asm define: BSP_DEFINES_ONLY BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET NRF52
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../: main.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/rtc/: nrf_drv_rtc.c
    ../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
